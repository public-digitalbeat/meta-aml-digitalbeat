SYSTEMD_SERVICE_${PN} = "wifi.service"
