SYSTEMD_SERVICE_${PN} = "binder.service"
